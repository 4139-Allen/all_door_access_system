# Keil uVision project stm32_template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Sample +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\Libraries\CMSIS\Startup;..\Libraries\CMSIS;..\Libraries\FWLib\inc;..\User;..\System\delay;..\System\sys;..\System\usart;..\Hardware\Martix_KEY;..\Hardware\RC522;..\Hardware\lcd12864;..\Hardware\AT24CXX;..\Hardware\AS608;..\Hardware\General_Module;..\Hardware\IIC;..\System\timer;..\User\menu;..\User\password;..\Hardware\W5500
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Libraries/CMSIS/Startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLib
    ../Libraries/FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
    ../User/menu/: menu.c
    ../User/password/: password.c
  group DOC
    ../DOC/: Readme.txt
  group SYSTEM
    ../System/sys/: sys.c
    ../System/delay/: delay.c
    ../System/usart/: usart.c
    ../System/timer/: timer.c
  group HARDWARE
    ../Hardware/RC522/: rc522_config.c rc522_function.c
    ../Hardware/Martix_KEY/: Martix_KEY.c
    ../Hardware/AS608/: AS608.c
    ../Hardware/AT24CXX/: AT24CXX.c
    ../Hardware/General_Module/: General_Module.c
    ../Hardware/LCD12864/: lcd12864.c
    ../Hardware/IIC/: myiic.c
    ../Hardware/W5500/: w5500.c mqtt_client.c
